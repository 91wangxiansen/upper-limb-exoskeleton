#pragma once
#include <Arduino.h>
#include <Wire.h>
#include <string.h>

// SSD1306 128x32, SDA=21, SCL=22. No external display library required.
class HandOLED {
public:
  bool begin() {
    Wire.begin(21,22,400000); Wire.setTimeOut(10);
    address=0x3c;
    if(!probe()) { address=0x3d; if(!probe()) return false; }
    const uint8_t init[]={0xae,0xd5,0x80,0xa8,0x1f,0xd3,0x00,0x40,
      0x8d,0x14,0x20,0x00,0xa1,0xc8,0xda,0x02,0x81,0x8f,
      0xd9,0xf1,0xdb,0x40,0xa4,0xa6,0xaf};
    ready=commands(init,sizeof(init)); return ready;
  }
  bool available() const { return ready; }
  void show(const char* a,const char* b,const char* c,const char* d) {
    if(!ready) return;
    const char* rows[]={a,b,c,d}; uint8_t pixels[512]{};
    for(int row=0;row<4;++row) {
      for(int column=0;column<21 && rows[row][column];++column) {
        const uint8_t* glyph=font(rows[row][column]);
        for(int x=0;x<5;++x) pixels[row*128+column*6+x]=glyph[x];
      }
    }
    const uint8_t window[]={0x21,0,127,0x22,0,3};
    if(!commands(window,sizeof(window))) { ready=false; return; }
    for(size_t offset=0;offset<sizeof(pixels);offset+=16) {
      Wire.beginTransmission(address); Wire.write(uint8_t(0x40));
      Wire.write(pixels+offset,16);
      if(Wire.endTransmission()!=0) { ready=false; return; }
    }
  }
private:
  uint8_t address=0x3c; bool ready=false;
  bool probe() { Wire.beginTransmission(address); return Wire.endTransmission()==0; }
  bool commands(const uint8_t* bytes,size_t length) {
    Wire.beginTransmission(address); Wire.write(uint8_t(0x00));
    Wire.write(bytes,length); return Wire.endTransmission()==0;
  }
  static const uint8_t* font(char c) {
    static const uint8_t blank[5]={};
    static const uint8_t numbers[10][5]={
      {0x3e,0x51,0x49,0x45,0x3e},{0,0x42,0x7f,0x40,0},
      {0x42,0x61,0x51,0x49,0x46},{0x21,0x41,0x45,0x4b,0x31},
      {0x18,0x14,0x12,0x7f,0x10},{0x27,0x45,0x45,0x45,0x39},
      {0x3c,0x4a,0x49,0x49,0x30},{1,0x71,9,5,3},
      {0x36,0x49,0x49,0x49,0x36},{6,0x49,0x49,0x29,0x1e}};
    static const uint8_t letters[26][5]={
      {0x7e,0x11,0x11,0x11,0x7e},{0x7f,0x49,0x49,0x49,0x36},
      {0x3e,0x41,0x41,0x41,0x22},{0x7f,0x41,0x41,0x22,0x1c},
      {0x7f,0x49,0x49,0x49,0x41},{0x7f,9,9,9,1},
      {0x3e,0x41,0x49,0x49,0x7a},{0x7f,8,8,8,0x7f},
      {0,0x41,0x7f,0x41,0},{0x20,0x40,0x41,0x3f,1},
      {0x7f,8,0x14,0x22,0x41},{0x7f,0x40,0x40,0x40,0x40},
      {0x7f,2,0x0c,2,0x7f},{0x7f,4,8,0x10,0x7f},
      {0x3e,0x41,0x41,0x41,0x3e},{0x7f,9,9,9,6},
      {0x3e,0x41,0x51,0x21,0x5e},{0x7f,9,0x19,0x29,0x46},
      {0x46,0x49,0x49,0x49,0x31},{1,1,0x7f,1,1},
      {0x3f,0x40,0x40,0x40,0x3f},{0x1f,0x20,0x40,0x20,0x1f},
      {0x7f,0x20,0x18,0x20,0x7f},{0x63,0x14,8,0x14,0x63},
      {3,4,0x78,4,3},{0x61,0x51,0x49,0x45,0x43}};
    static const uint8_t punctuation[][5]={
      {0,0,0x5f,0,0},{8,8,0x3e,8,8},{8,8,8,8,8},
      {0,0x60,0x60,0,0},{0x20,0x10,8,4,2},{0,0x36,0x36,0,0},
      {2,1,0x51,9,6},{0x40,0x40,0x40,0x40,0x40},
      {0x41,0x22,0x14,8,0},{0,0x50,0x30,0,0}};
    if(c>='a' && c<='z') c-=('a'-'A');
    if(c>='0' && c<='9') return numbers[c-'0'];
    if(c>='A' && c<='Z') return letters[c-'A'];
    const char* keys="!+-./:?_>,";
    const char* found=strchr(keys,c);
    return c && found?punctuation[found-keys]:blank;
  }
};
